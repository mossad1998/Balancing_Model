# IAR project Balancing_Model_V_5.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: TM4C123GH6PM TexasInstruments TM4C123GH6PM
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: Control.c Control.h GPIO_Driver.c GPIO_Driver.h GPTM_Driver.c GPTM_Driver.h Interrupt_Driver.c Interrupt_Driver.h Intializations.c Intializations.h main.c PWM_Driver.c PWM_Driver.h startup_ewarm.c Systick_Timer.c Systick_Timer.h tm4c123gh6pm.h
